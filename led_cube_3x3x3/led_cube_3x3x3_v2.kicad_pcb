# Repository kobialka/KiCad

File README.md:

#KiCad projects

1. usb_rs232_v1:
	3 w 1: konwerter USB <=>UART, USB <=> RS232, pinoutbox dla RS232. 
	Układy FT232B WYMAGAJĄ zewnętrznego rezonatora 6MHz. Stosować FT232R.
2. led_cube_3x3x3:
	Na układzie STC2210.

## KiCad design led_cube_3x3x3/led_cube_3x3x3_v2.kicad_pcb

Parts:
C1, C3, C7, C8, C9, C12, C13: 100n
C2, C14: 10u
C10, C11: 33p
D1: LED_CUBE_3X3X3
D2: 5v1
IC1: ATMEGA8A-P; DIL28
J1: Supply
J2: ISP; AVR-ISP-6
J4: UART
L1: 15uH
Q1, Q2, Q3: A1015
Q4: SFH320
R1, R2, R3, R11: 10k
R4: 20R
R5, R7, R9: 230R
R6, R8, R10: 0R
R12, R14, R16, R18, R20, R22, R24, R26, R28: NF
R13, R15, R17, R19, R21, R23, R25, R27, R29, R32, R33: 100R
R30: 20R; SM0805
R31: 1k1
R34: 2k
U1: ST2221C
U2: 24C512
X1: 16MHz

Connections:
+5V: C1.2, C2.1, C3.2, D2.2, J1.1, J2.2, Q1.1 (E), Q2.1 (E), Q3.1 (E), R1.2, R2.2, R3.2, R4.1, R30.1
/A1C: D1.10 (D1x), Q1.2 (C)
/A2C: D1.11 (D2x), Q2.2 (C)
/A3C: D1.12 (D3x), Q3.2 (C)
/ARef: C9.1, IC1.21 (AREF)
/AVcc: C8.1, IC1.20 (AVCC), L1.2
/C1: D1.1 (Dx1), R12.2, R13.2
/C2: D1.2 (Dx2), R14.2, R15.2
/C3: D1.3 (Dx3), R16.2, R17.2
/C4: D1.4 (Dx4), R18.2, R19.2
/C5: D1.5 (Dx5), R20.2, R21.2
/C6: D1.6 (Dx6), R22.2, R23.2
/C7: D1.7 (Dx7), R24.2, R25.2
/C8: D1.8 (Dx8), R26.2, R27.2
/C9: D1.9 (Dx9), R28.2, R29.2
/uCVcc: C7.1, C12.1, IC1.7 (VCC), L1.1, R4.2, R11.2, R34.2, U2.1 (A0), U2.2 (A1), U2.8 (VCC)
CLK: IC1.16 ((~SS~/OC1B)PB2), U1.3 (CLK)
GND: C1.1, C2.2, C3.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, D2.1, IC1.8 (GND), IC1.22 (AGND), J1.2 (PM), J2.6, J4.3, Q4.1 (E), R31.1, U1.1 (GND), U2.3 (A2), U2.4 (GND)
ISP MISO: IC1.18 ((MISO)PB4), J2.1
ISP MOSI: IC1.17 ((MOSI/OC2)PB3), J2.4
ISP RST: IC1.1 (PC6(~RESET~)), J2.5, R11.1
ISP SCK: IC1.19 ((SCK)PB5), J2.3
LA: IC1.14 ((ICP)PB0), U1.4 (LA/)
LIGHT_SENS: IC1.23 ((ADC0)PC0), Q4.2 (C), R34.1
Lev_1: IC1.26 ((ADC3)PC3), R5.1
Lev_2: IC1.25 ((ADC2)PC2), R7.1
Lev_3: IC1.24 ((ADC1)PC1), R9.1
unnamed: C11.1, IC1.10 (PB7(XTAL2/TOSC2)), X1.1
unnamed: C13.2, C14.1, R30.2, U1.24 (VDD)
unnamed: R33.2, U1.23 (REXT)
unnamed: C10.1, IC1.9 (PB6(XTAL1/TOSC1)), X1.2
unnamed: Q3.3 (B), R3.1, R10.1
unnamed: R32.1, R33.1
unnamed: R31.2, R32.2
unnamed: Q2.3 (B), R2.1, R8.1
unnamed: Q1.3 (B), R1.1, R6.1
unnamed: R5.2, R6.2
unnamed: R7.2, R8.2
unnamed: R9.2, R10.2
OE: IC1.15 ((OC1A)PB1), U1.21 (OE/)
RxD: IC1.2 ((RXD)PD0), J4.2 (PM)
SCL: IC1.28 ((ADC5/SCL)PC5), U2.6 (SCL)
SDA: IC1.27 ((ADC4/SDA)PC4), U2.5 (SDA)
SDI: IC1.13 ((AIN1)PD7), U1.2 (SDI)
TxD: IC1.3 ((TXD)PD1), J4.1
Vert_1: R12.1, R13.1, U1.9 (O4)
Vert_2: R14.1, R15.1, U1.7 (O2)
Vert_3: R16.1, R17.1, U1.6 (O1)
Vert_4: R18.1, R19.1, U1.10 (O5)
Vert_5: R20.1, R21.1, U1.13 (O8)
Vert_6: R22.1, R23.1, U1.5 (O0)
Vert_7: R24.1, R25.1, U1.11 (O6)
Vert_8: R26.1, R27.1, U1.12 (O7)
Vert_9: R28.1, R29.1, U1.8 (O3)
WP: IC1.4 ((INT0)PD2), U2.7 (WP)

Notes on the sheet:
MAX 75mA per output
150mA
LEDs
Constant Current LED Driver
EEPROM
ISP
Microcontroller
Light sens
Supply
UART

Board: 2 copper layers, 66.0 x 66.0 mm, 59 parts (24 on the bottom side), 55 nets.

## KiCad design usb_rs232_v1/usb_rs232_converter_v1.kicad_pcb

Parts:
C1, C3: 27p
C2: 33n
C4: 10u
C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C16: 100n
C15: 4n7
CON1: USB-micro-B
CON2: USB-mini-B
D1: RED
D2: GREEN
D3: TxD
D4: RxD
D5: RTS
D6: CTS
D7: DTR
D8: DSR
D9: DCD
D10: RI
F1, F2: 500mA
IC1: FT232BL
IC2: MAX3243
J1: COM LEFT
J2: COM LEFT COM; con-hdrs40-SIP-100-8V
J3: COM RIGHT COM; con-hdrs40-SIP-100-8V
J4: UART; con-hdrs40-SIP-100-5V
J6: COM RIGHT
J7: FTDI; con-hdrs40-SIP-100-8V
J8: COM RIGHT FTDI; con-hdrs40-SIP-100-8V
L1: 15uH
R5, R6: 27R
R7: 1k5
R8, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19: 470R
VR1: MC78L33
X1: QUARTZCMS4_M

Connections:
+3.3V: C7.2, C10.1, C13.2, IC1.13 (VCCIO), IC2.22 (FORCEOFF), IC2.23 (FORCEON), IC2.26 (VCC), J4.2, R10.1, R11.1, VR1.3 (OUT)
+5V: C4.1, C6.2, C14.2, C16.2, IC1.3 (VCC), IC1.26 (VCC), J4.1, L1.2, R8.1, VR1.2 (IN)
/AVCC: C5.2, IC1.30 (AVCC), R8.2
/CTS COM: D6.2 (K), J3.4, J6.8, J8.4
/CTS COM LEFT: J1.8, J2.4
/D+: CON1.3 (D+), CON2.3 (D+), R6.1
/D++: IC1.7 (USBDP), R6.2, R7.2
/D-: CON1.2 (D-), CON2.2 (D-), R5.1
/D--: IC1.8 (USBDM), R5.2
/DCD COM: D9.2 (K), J3.2, J6.1, J8.2
/DCD COM LEFT: J1.1, J2.2
/DSR COM: D8.2 (K), J3.3, J6.6, J8.3
/DSR COM LEFT: J1.6, J2.3
/DTR COM: D7.2 (K), J3.7, J6.4, J8.7
/DTR COM LEFT: J1.4, J2.7
/RI COM: D10.2 (K), J3.1, J6.9, J8.1
/RI COM LEFT: J1.9, J2.1
/RST COM: D5.2 (K), J3.8, J6.7, J8.8
/RST COM LEFT: J1.7, J2.8
/RX LED: D2.2 (K), IC1.11 (~RXLED)
/Rin: CTS: IC2.7 (RIN4), J7.4
/Rin: DCD: IC2.5 (RIN2), J7.2
/Rin: DSR: IC2.6 (RIN3), J7.3
/Rin: RI: IC2.4 (RIN1), J7.1
/Rin: RxD: IC2.8 (RIN5), J7.5
/Rout: CTS: IC1.22 (D3/~CTS), IC2.16 (ROUT4)
/Rout: DCD: IC1.19 (D6/~DCD), IC2.18 (ROUT2)
/Rout: DSR: IC1.20 (D5/~DSR), IC2.17 (ROUT3)
/Rout: RI: IC1.18 (D7/~RI), IC2.19 (ROUT1)
/Rout: RxD: IC1.24 (D1/RXD), IC2.15 (ROUT5), J4.3
/RxD COM: D4.2 (K), J3.5, J6.2, J8.5
/RxD COM LEFT: J1.2, J2.5
/TX LED: D1.2 (K), IC1.12 (~TXLED)
/Tin: DTR: IC1.21 (D4/~DTR), IC2.13 (TIN2)
/Tin: RST: IC1.23 (D2/~RST), IC2.12 (TIN3)
/Tin: TxD: IC1.25 (D0/TXD), IC2.14 (TIN1), J4.4
/Tout: DTR: IC2.10 (TOUT2), J7.7
/Tout: RST: IC2.11 (TOUT3), J7.8
/Tout: TxD: IC2.9 (TOUT1), J7.6
/TxD COM: D3.2 (K), J3.6, J6.3, J8.6
/TxD COM LEFT: J1.3, J2.6
/XTIN: C1.1, IC1.27 (XTIN), X1.1
/XTOUT: C3.1, IC1.28 (XTOUT), X1.2
GND: C1.2, C2.1, C3.2, C4.2, C5.1, C6.1, C7.1, C9.1, C10.2, C12.2, C13.1, C14.1, C16.1, F2.1, IC1.9 (GND), IC1.14 (PWRCTL), IC1.17 (GND), IC1.29 (AGND), IC1.31 (TEST), IC2.25 (GND), J1.5, J4.5, J6.5, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, VR1.1 (GND)
unnamed: C9.2, IC2.3 (v-)
unnamed: C11.2, IC2.24 (C1-)
unnamed: C11.1, IC2.28 (C1+)
unnamed: D3.1 (A), R12.1
unnamed: C8.1, IC2.2 (C2-)
unnamed: C8.2, IC2.1 (C2+)
unnamed: C12.1, IC2.27 (V+)
unnamed: D2.1 (A), R11.2
unnamed: D1.1 (A), R10.2
unnamed: D10.1 (A), R19.1
unnamed: D9.1 (A), R18.1
unnamed: D8.1 (A), R17.1
unnamed: D7.1 (A), R16.1
unnamed: D6.1 (A), R15.1
unnamed: D5.1 (A), R14.1
unnamed: D4.1 (A), R13.1
unnamed: C15.1, CON1.5 (GND), CON1.8 (SHELL3), CON2.5 (GND), CON2.6 (SHELL1), F2.2
unnamed: C2.2, IC1.6 (3V3OUT), R7.1
unnamed: F1.2, L1.1
unnamed: C15.2, CON1.1 (VBUS), CON2.1 (VBUS), F1.1

Notes on the sheet:
Można dodać na wyjścia zasilające: - diody zenera 3.6, 5.5 - kondensatorki 100n - ewentualnie ferryt

Board: 2 copper layers, 85.0 x 51.0 mm, 56 parts (22 on the bottom side), 64 nets.

## Commit log

2015-06-03 New project: usb-uart-rs232 board
2015-06-03 Dodane biblioteki z sieci
2015-06-03 Sprawdzone footprinty
2015-06-04 Schemat v1
2015-06-04 Pcb v0.1
2015-06-09 Pcb v0.2
2015-06-10 PCB v1.0 BIG
2015-06-10 PCB v1.1 poligony
2015-06-28 usb_rs232 pcb_v2.0
2015-06-28 test commit
2016-02-07 usb_rs232: v2.1: poprawiony footprint VR1
2016-09-21 started schematics for led cube
2016-10-09 led cube sch v1
2016-10-25 led cube pcb v0.1
2016-10-25 led cube pcb v0.2
2016-10-30 led cube pcb v1.0
2016-12-02 led cube sch pcp v2.0
2016-12-02 led cube pcb v2.1
